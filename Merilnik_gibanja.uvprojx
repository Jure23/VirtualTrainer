# Keil uVision project Merilnik_gibanja.uvprojx, settings and files
target SamD20J18 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAMD20J18 Atmel
  pack: Keil.SAMD20_DFP.1.1.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Merilnik_gibanja
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group low_level_drivers
    ./: clock.c gpio.c trp868_uart.c hr_timer.c delay.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 1.0.0
